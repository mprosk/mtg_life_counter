# Repository mprosk/mtg_life_counter

File README.md:

# MTG Life Counter v3

Four player life counter for *Magic: The Gathering*

**Version 2 software is still WIP, hardware is stable**

Check out the [Version 1 branch](https://github.com/mprosk/mtg_life_counter/tree/v1_tht) (pictured below)

## v2 Software To Do

- Improve denounce of encoders
- Change modes by clicking encoder button once
  - Clicking the button after changing a non-self value returns directly to self view

- Do not show deltas on non-self values
- Allow Roll result be cleared by any input
- Possibly use `micros()` for RNG

## Features

- Easily track the life of up to four players
- Each player can track poison counters and commander damage from the other three players, including partner commanders
- Supported life totals of -999 to 9999
- Selectable starting life of 20, 30, or 40
- "Roll" button for randomly selecting the starting player

## Hardware

- ATmega328P (Arduino Nano)
- 4x common cathode 4-digit 7-segment displays
- 4x rotary encoders with switches and detents
- 2x 12mm tactile switches
- 4x 74HC595 for segment driving
- 2x TPIC6B595 for sinking digit current
- 1x 74HC165 for encoder capture

## Theory of Operation

There are two main subsystems within the counter's design, the control input sensing, and the 7-segment display driver.

## Operating Instructions

### Power

1. Plug a USB Type C cable into the connector and set the power switch to ON. The display will initialize to the selected starting life total
5. To turn off the display, move the power switch to the OFF position or unplug the USB cable

### Starting Life

Use the 20/40 switch to select the starting life totals. Changing this switch will reset the life counters!

To select a starting life of 30, press and hold the yellow reset button while changing the 20/40 switch. The setting of the switch does not matter so long as the reset button is held while it is changed

### Tracking Life and Damage

Each player uses one corner of the board, which contains the 7-segment display, and a rotary encoder for changing the counter's value, and selecting the display mode

#### Selecting Display Mode

TODO

#### Changing the Value

Once the desired mode has been selected, adjust that value by rotating the encoder

When the encoder is adjusted, the counter will show the change in value that is being entered. After a brief timeout, the display will switch to showing the new updated value

#### Resetting the Counters

To reset **ALL** the counters, press the yellow reset button in the middle of the board

You can also reset an individual counter by pressing both the directional buttons for that counter at the same time

### Roll Button

The ROLL button on the counter allows you to quickly and easily select a player at random, useful for determining which player starts, or even for randomly selecting which player you should deal damage to.

To activate this feature, press and hold the blue ROLL button in the middle of the counter. When you are ready, release the button, and the random output will be shown on the displays. The result disappears after a few seconds.

For two-player games, simply use whichever half of the device the play lands on to determine starting player

#### Random Number Generation

While the device is on, there is a counter being continuously incremented. When the ROLL button is released, the value of this counter `mod` 4 determines which player won the roll. This counter increments approximately  250,000 times per second, so it is virtually impossible for a human to actuate the button with enough precision to influence the output of the roll.

## Next Hardware Revision

List of features and fixes that may be considered in a potential next hardware revision

- SMD buttons, resonator
- Replace encoders with buttons
  - Remove 74HC165 - wire buttons direct to Atmega
  - Use double button push to change modes
- Battery power
- https://www.luckylight.cn/en/products/led-display/smd-7-segment-display/

| Color | I<sub>F</sub> | V<sub>F</sub>                                 | R                                                            | Lum          |
| ----- | ------------- | --------------------------------------------- | ------------------------------------------------------------ | ------------ |
| Red   | 20mA          | 2.0V @ 20mA<br />1.9V @ 15mA<br />1.8V @ 10mA | (5V - 2.0V) / 20mA = 150R<br />(5V - 1.8V) / 10ma = ~**330R** | 26mcd @ 10mA |
| Amber | 20mA          | 2.1V @ 20mA<br />2.0V @ 15mA<br />1.9V @ 10mA | (5V - 2.1V) / 20mA = ~150R<br />(5V - 1.9V) / 10mA = ~**330R** | 28mcd @ 10mA |
| Green | 20mA          | 2.0V @ 20mA                                   | (5V - 2.0V) / 20mA = **150R**                                | 9mcd @ 10mA  |
| Blue  | 10mA          | 2.9V @ 10mA<br />2.8V @ 7.5mA<br />2.7V @ 5mA | (5v - 2.9V) / 10mA = ~**220R**                               | 25mcd @ 10mA |

 160mA total per digit

640mA total 

'

- Common Anode + 4x TPIC + high side switching FETs
- Common cathode + 4x 595 + high side switching FETs + low side switching FETs

TPIC = $1.31

595 = $0.54

## KiCad design pcb/mtg_life_counter.kicad_pcb

Parts:
B1: P1 UP; SW_SPST_WE_WS-TASV_12mm_Tac
B2: P1 DOWN; SW_SPST_WE_WS-TASV_12mm_Tac
B3: P2 UP; SW_SPST_WE_WS-TASV_12mm_Tac
B4: P2 DOWN; SW_SPST_WE_WS-TASV_12mm_Tac
B5: P3 UP; SW_SPST_WE_WS-TASV_12mm_Tac
B6: P3 DOWN; SW_SPST_WE_WS-TASV_12mm_Tac
B7: P4 UP; SW_SPST_WE_WS-TASV_12mm_Tac
B8: P4 DOWN; SW_SPST_WE_WS-TASV_12mm_Tac
B9: RESET; SW_SPST_WE_WS-TASV_12mm_Tac
B10: ROLL; SW_SPST_WE_WS-TASV_12mm_Tac
C1: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C4: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D5: PJSD05W_R1_00001; D_SOD-323_HandSoldering
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3
J1: GCT USB-4135-GF-A; USB_C_Receptacle_GCT_USB4135-GF-A_6P_TopMnt_Horizontal
J2: ICSP; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
J3: TP_UART; TP_Edge_6
R1, R4, R5, R6, R7: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R3: 5.1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1, SW2: MODE SW; SW_SPDT_CK_JS102011JCQN; Part CK JS102011JCQN
TP1: LATCH; TestPoint_Pad_D1.5mm
TP2: COPI; TestPoint_Pad_D1.5mm
TP3: SCLK; TestPoint_Pad_D1.5mm
TP4: GND; TestPoint_Pad_D1.5mm
TP5: 5V; TestPoint_Pad_D1.5mm
U1: ATmega328P-AU; TQFP-32_7x7mm_P0.8mm
Y1: 16MHz; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm_HandSoldering

Connections:
+5V: C1.2, C2.2, C3.2, C4.2, C5.2, J2.2, J3.3, R1.2, R4.1, R5.1, R6.1, R7.1, SW1.1 (A), TP5.1, U1.4 (VCC), U1.6 (VCC), U1.18 (AVCC); also elsewhere on the board
/A6: U1.19 (ADC6)
/A7: U1.22 (ADC7)
/AREF: U1.20 (AREF)
/BTN_P1_DN: B2.1, J3.4, U1.30 (PD0(RXD))
/BTN_P1_UP: B1.1, U1.32 (PD2(INT0))
/BTN_P2_DN: B4.1, U1.28 (PC5(SCL/ADC5))
/BTN_P2_UP: B3.1, U1.27 (PC4(SDA/ADC4))
/BTN_P3_DN: B6.1, U1.9 (PD5)
/BTN_P3_UP: B5.1, U1.10 (PD6)
/BTN_P4_DN: B8.1, U1.2 (PD4)
/BTN_P4_UP: B7.1, U1.1 (PD3(INT1))
/BTN_RESET: B9.1, U1.13 (PB1)
/BTN_ROLL: B10.1, U1.12 (PB0(ICP))
/CIPO: J2.1, U1.16 (PB4(MISO))
/COPI: J2.4, TP2.1, U1.15 (PB3(MOSI)); also elsewhere on the board
/DIGIT_SEL_1: R4.2, U1.23 (PC0(ADC0)); also elsewhere on the board
/DIGIT_SEL_2: R5.2, U1.24 (PC1(ADC1)); also elsewhere on the board
/DIGIT_SEL_3: R6.2, U1.25 (PC2(ADC2)); also elsewhere on the board
/DIGIT_SEL_4: R7.2, U1.26 (PC3(ADC3)); also elsewhere on the board
/LATCH: TP1.1, U1.11 (PD7); also elsewhere on the board
/MODE_SW: SW2.2 (B), U1.14 (PB2(CS))
/SCLK: J2.3, TP3.1, U1.17 (PB5(SCK)); also elsewhere on the board
/TX: J3.5, U1.31 (PD1(TXD))
/XTAL1: U1.7 (XTAL1(PB6)), Y1.1
/XTAL2: U1.8 (XTAL2(PB7)), Y1.3
/~RESET: J2.5, R1.1, U1.29 (~RESET(PC6))
GND: B1.2, B2.2, B3.2, B4.2, B5.2, B6.2, B7.2, B8.2, B9.2, B10.2, C1.1, C2.1, C3.1, C4.1, C5.1, D5.2 (A2), J1.A12 (GND), J1.B12 (GND), J1.S1 (SHELL), J2.6, J3.1, R2.2, R3.2, SW2.1 (A), TP4.1, U1.3 (GND), U1.5 (GND), U1.21 (AGND), Y1.2; also elsewhere on the board
unnamed: J1.A5 (CC1), R2.1
unnamed: J1.B5 (CC2), R3.1
VBUS: D5.1 (A1), J1.A9 (VBUS), J1.B9 (VBUS), SW1.2 (B)

Notes on the sheet:
D0(RX)
D2(INT0)
Player 2 Display Bank - Green
Player 3 Display Bank - Amber
D12(CIPO)
Arduino
D3(INT1)
D1(TX)
Player Up/Down Buttons
Player 4 Display Bank - Blue
Player 1 Display Bank - Red
D10
D13(SCK)
D11(COPI)

Parts:
C7: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D2: KD4-S561AGB-G5; KD4-S561xxB_SMD_Slim
Q5, Q6, Q7, Q8: DMG2301L; SOT-23
R20, R21, R22, R23: 330R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R24, R25, R26, R27, R28, R29, R30, R31: 220R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U3: TPIC6C596; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+5V: C7.1, Q5.3 (D), Q6.3 (D), Q7.3 (D), Q8.3 (D), U3.1 (VCC), U3.7 (~SRCLR); also elsewhere on the board
/DIGIT_SEL_1: R20.1; also elsewhere on the board
/DIGIT_SEL_2: R21.1; also elsewhere on the board
/DIGIT_SEL_3: R22.1; also elsewhere on the board
/DIGIT_SEL_4: R23.1; also elsewhere on the board
/LATCH: U3.10 (RCLK); also elsewhere on the board
/P2/AA: D2.11 (a), R24.1
/P2/AB: D2.7 (b), R25.1
/P2/AC: D2.4 (c), R26.1
/P2/AD: D2.2 (d), R27.1
/P2/ADP: D2.3 (DP), R31.1
/P2/AE: D2.1 (e), R28.1
/P2/AF: D2.10 (f), R29.1
/P2/AG: D2.5 (g), R30.1
/P2/CA1: D2.12 (CA1), Q5.2 (S)
/P2/CA2: D2.9 (CA2), Q6.2 (S)
/P2/CA3: D2.8 (CA3), Q7.2 (S)
/P2/CA4: D2.6 (CA4), Q8.2 (S)
/P2/SA: R24.2, U3.3 (DRAIN0)
/P2/SB: R25.2, U3.4 (DRAIN1)
/P2/SC: R26.2, U3.5 (DRAIN2)
/P2/SD: R27.2, U3.6 (DRAIN3)
/P2/SDP: R31.2, U3.14 (DRAIN7)
/P2/SE: R28.2, U3.11 (DRAIN4)
/P2/SF: R29.2, U3.12 (DRAIN5)
/P2/SG: R30.2, U3.13 (DRAIN6)
/SCLK: U3.15 (SRCK); also elsewhere on the board
/SHIFT_CARRY_2: U3.2 (SER_IN); also elsewhere on the board
/SHIFT_CARRY_3: U3.9 (SER_OUT); also elsewhere on the board
GND: C7.2, U3.8 (~G), U3.16 (GND); also elsewhere on the board
unnamed: Q5.1 (G), R20.2
unnamed: Q6.1 (G), R21.2
unnamed: Q7.1 (G), R22.2
unnamed: Q8.1 (G), R23.2

Notes on the sheet:
I_{F}_TARGET = 10mA V_{F} = 2.9V @ 10mA (5V - 2.9V) / 0.010A = 220R

Parts:
C9: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D4: KD4-S561ABB; KD4-S561xxB_SMD_Slim
Q13, Q14, Q15, Q16: DMG2301L; SOT-23
R44, R45, R46, R47: 330R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R48, R49, R50, R51, R52, R53, R54, R55: 150R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U5: TPIC6C596; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+5V: C9.1, Q13.3 (D), Q14.3 (D), Q15.3 (D), Q16.3 (D), U5.1 (VCC), U5.7 (~SRCLR); also elsewhere on the board
/COPI: U5.2 (SER_IN); also elsewhere on the board
/DIGIT_SEL_1: R44.1; also elsewhere on the board
/DIGIT_SEL_2: R45.1; also elsewhere on the board
/DIGIT_SEL_3: R46.1; also elsewhere on the board
/DIGIT_SEL_4: R47.1; also elsewhere on the board
/LATCH: U5.10 (RCLK); also elsewhere on the board
/P4/AA: D4.11 (a), R48.1
/P4/AB: D4.7 (b), R49.1
/P4/AC: D4.4 (c), R50.1
/P4/AD: D4.2 (d), R51.1
/P4/ADP: D4.3 (DP), R55.1
/P4/AE: D4.1 (e), R52.1
/P4/AF: D4.10 (f), R53.1
/P4/AG: D4.5 (g), R54.1
/P4/CA1: D4.12 (CA1), Q13.2 (S)
/P4/CA2: D4.9 (CA2), Q14.2 (S)
/P4/CA3: D4.8 (CA3), Q15.2 (S)
/P4/CA4: D4.6 (CA4), Q16.2 (S)
/P4/SA: R48.2, U5.3 (DRAIN0)
/P4/SB: R49.2, U5.4 (DRAIN1)
/P4/SC: R50.2, U5.5 (DRAIN2)
/P4/SD: R51.2, U5.6 (DRAIN3)
/P4/SDP: R55.2, U5.14 (DRAIN7)
/P4/SE: R52.2, U5.11 (DRAIN4)
/P4/SF: R53.2, U5.12 (DRAIN5)
/P4/SG: R54.2, U5.13 (DRAIN6)
/SCLK: U5.15 (SRCK); also elsewhere on the board
/SHIFT_CARRY_1: U5.9 (SER_OUT); also elsewhere on the board
GND: C9.2, U5.8 (~G), U5.16 (GND); also elsewhere on the board
unnamed: Q13.1 (G), R44.2
unnamed: Q14.1 (G), R45.2
unnamed: Q15.1 (G), R46.2
unnamed: Q16.1 (G), R47.2

Notes on the sheet:
I_{F}_TARGET = 15mA V_{F} = 2.95V @ 15mA (5V - 2.95) / 0.015A = 150R

Parts:
C6: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: KD4-S561AVB; KD4-S561xxB_SMD_Slim
Q1, Q2, Q3, Q4: DMG2301L; SOT-23
R8, R9, R10, R11: 330R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R12, R13, R14, R15, R16, R17, R18, R19: 270R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U2: TPIC6C596; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+5V: C6.1, Q1.3 (D), Q2.3 (D), Q3.3 (D), Q4.3 (D), U2.1 (VCC), U2.7 (~SRCLR); also elsewhere on the board
/DIGIT_SEL_1: R8.1; also elsewhere on the board
/DIGIT_SEL_2: R9.1; also elsewhere on the board
/DIGIT_SEL_3: R10.1; also elsewhere on the board
/DIGIT_SEL_4: R11.1; also elsewhere on the board
/LATCH: U2.10 (RCLK); also elsewhere on the board
/P1/AA: D1.11 (a), R12.1
/P1/AB: D1.7 (b), R13.1
/P1/AC: D1.4 (c), R14.1
/P1/AD: D1.2 (d), R15.1
/P1/ADP: D1.3 (DP), R19.1
/P1/AE: D1.1 (e), R16.1
/P1/AF: D1.10 (f), R17.1
/P1/AG: D1.5 (g), R18.1
/P1/CA1: D1.12 (CA1), Q1.2 (S)
/P1/CA2: D1.9 (CA2), Q2.2 (S)
/P1/CA3: D1.8 (CA3), Q3.2 (S)
/P1/CA4: D1.6 (CA4), Q4.2 (S)
/P1/SA: R12.2, U2.3 (DRAIN0)
/P1/SB: R13.2, U2.4 (DRAIN1)
/P1/SC: R14.2, U2.5 (DRAIN2)
/P1/SD: R15.2, U2.6 (DRAIN3)
/P1/SDP: R19.2, U2.14 (DRAIN7)
/P1/SE: R16.2, U2.11 (DRAIN4)
/P1/SF: R17.2, U2.12 (DRAIN5)
/P1/SG: R18.2, U2.13 (DRAIN6)
/P1/SHIFT_OUT: U2.9 (SER_OUT)
/SCLK: U2.15 (SRCK); also elsewhere on the board
/SHIFT_CARRY_3: U2.2 (SER_IN); also elsewhere on the board
GND: C6.2, U2.8 (~G), U2.16 (GND); also elsewhere on the board
unnamed: Q1.1 (G), R8.2
unnamed: Q2.1 (G), R9.2
unnamed: Q3.1 (G), R10.2
unnamed: Q4.1 (G), R11.2

Notes on the sheet:
I_{F}_TARGET = 12.5mA V_{F} = 1.85V @ 12.5mA (5V - 1.85V) / 0.0125A = 270R

Parts:
C8: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D3: KD4-S561AAB; KD4-S561xxB_SMD_Slim
Q9, Q10, Q11, Q12: DMG2301L; SOT-23
R32, R33, R34, R35: 330R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R36, R37, R38, R39, R40, R41, R42, R43: 150R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U4: TPIC6C596; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+5V: C8.1, Q9.3 (D), Q10.3 (D), Q11.3 (D), Q12.3 (D), U4.1 (VCC), U4.7 (~SRCLR); also elsewhere on the board
/DIGIT_SEL_1: R32.1; also elsewhere on the board
/DIGIT_SEL_2: R33.1; also elsewhere on the board
/DIGIT_SEL_3: R34.1; also elsewhere on the board
/DIGIT_SEL_4: R35.1; also elsewhere on the board
/LATCH: U4.10 (RCLK); also elsewhere on the board
/P3/AA: D3.11 (a), R36.1
/P3/AB: D3.7 (b), R37.1
/P3/AC: D3.4 (c), R38.1
/P3/AD: D3.2 (d), R39.1
/P3/ADP: D3.3 (DP), R43.1
/P3/AE: D3.1 (e), R40.1
/P3/AF: D3.10 (f), R41.1
/P3/AG: D3.5 (g), R42.1
/P3/CA1: D3.12 (CA1), Q9.2 (S)
/P3/CA2: D3.9 (CA2), Q10.2 (S)
/P3/CA3: D3.8 (CA3), Q11.2 (S)
/P3/CA4: D3.6 (CA4), Q12.2 (S)
/P3/SA: R36.2, U4.3 (DRAIN0)
/P3/SB: R37.2, U4.4 (DRAIN1)
/P3/SC: R38.2, U4.5 (DRAIN2)
/P3/SD: R39.2, U4.6 (DRAIN3)
/P3/SDP: R43.2, U4.14 (DRAIN7)
/P3/SE: R40.2, U4.11 (DRAIN4)
/P3/SF: R41.2, U4.12 (DRAIN5)
/P3/SG: R42.2, U4.13 (DRAIN6)
/SCLK: U4.15 (SRCK); also elsewhere on the board
/SHIFT_CARRY_1: U4.2 (SER_IN); also elsewhere on the board
/SHIFT_CARRY_2: U4.9 (SER_OUT); also elsewhere on the board
GND: C8.2, U4.8 (~G), U4.16 (GND); also elsewhere on the board
unnamed: Q9.1 (G), R32.2
unnamed: Q10.1 (G), R33.2
unnamed: Q11.1 (G), R34.2
unnamed: Q12.1 (G), R35.2

Notes on the sheet:
I_{F}_TARGET = 20mA V_{F} = 2.0V @ 20mA (5V - 2.0V) / 0.020A = 150R

Board: 2 copper layers, 167.6 x 101.6 mm, 115 parts (6 on the bottom side), 127 nets.
