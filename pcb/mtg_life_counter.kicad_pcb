# Repository mprosk/mtg_life_counter (continued)

## KiCad design mtg_life_counter/mtg_life_counter.kicad_pcb

Parts:
A1: Arduino_Nano_v3.x; Arduino_Nano
B1, B2, B3, B4, B5, B6, B7, B8, B9, B10: SW_Push; B3F_12mm
C1, C2, C3, C4, C5, C6, C7: 0.1uF; C_Disc_D3.0mm_W1.6mm_P2.50mm
D1, D2, D3, D4: KW4-56NX
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R33, R34: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R35: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RN1, RN2, RN3: 1000; R_Array_SIP9
SW1: SW_SPDT; SW_Slide_1P2T_CK_OS102011MS2Q
SW2: SW_SPST; SW_Slide_1P2T_CK_OS102011MS2Q
SW3, SW4, SW5, SW6: SW_SP4T; CK_RM10x77
U1, U3: 74HC595; DIP-16_W7.62mm
U2, U4: TPIC6595; DIP-20_W7.62mm
U5, U6, U7: 74LS151; DIP-16_W7.62mm

Connections:
+5V: A1.5 (D2), C1.2, C2.2, C3.2, C4.2, C5.1, C6.1, C7.1, R33.2, R34.2, RN1.1 (common), RN2.1 (common), RN3.1 (common), SW1.2 (B), U1.10 (~SRCLR), U1.16 (VCC), U2.2, U3.10 (~SRCLR), U3.16 (VCC), U4.2, U5.16 (VCC), U6.16 (VCC), U7.16 (VCC)
/5V_SRC: A1.27 (+5V), SW1.1 (A)
/BTN_RB: A1.23 (A4), U7.6 (~Z)
/INT_1: A1.6 (D3)
/MODE_SW: A1.20 (A1), SW2.1 (A)
/NENABLE: A1.11 (D8), U1.13 (~OE), U2.9, U3.13 (~OE), U4.9
/OFF: R35.2, SW1.3 (C)
/RESET_BTN: A1.10 (D7), B1.1
/RNG_WIRE: A1.19 (A0)
/ROLL_BTN: A1.9 (D6), B2.1
/SEL_0: A1.24 (A5), U5.11 (S0), U6.11 (S0), U7.11 (S0)
/SEL_1: A1.25 (A6), U5.10 (S1), U6.10 (S1), U7.10 (S1)
/SEL_2: A1.26 (A7), U5.9 (S2), U6.9 (S2), U7.9 (S2)
/SER_CASCADE_1: U1.9 (QH'), U3.14 (SER)
/SER_CASCADE_2: U2.3, U3.9 (QH')
/SER_CASCADE_3: U2.18, U4.3
/SER_CLK: A1.16 (D13), U1.11 (SRCLK), U2.13, U3.11 (SRCLK), U4.13
/SER_DATA: A1.14 (D11), U1.14 (SER)
/SER_LATCH: A1.12 (D9), U1.12 (RCLK), U2.12, U3.12 (RCLK), U4.12
/SPI_IN: A1.15 (D12)
/SW_RB_1: A1.22 (A3), U5.6 (~Z)
/SW_RB_2: A1.21 (A2), U6.6 (~Z)
GND: A1.4 (GND), A1.29 (GND), B1.2, B2.2, B3.2, B4.2, B5.2, B6.2, B7.2, B8.2, B9.2, B10.2, C1.1, C2.1, C3.1, C4.1, C5.2, C6.2, C7.2, H1.1, H2.1, H3.1, H4.1, R35.1, SW2.2 (B), SW3.1, SW4.1, SW5.1, SW6.1, U1.8 (GND), U2.10, U2.11, U2.19, U3.8 (GND), U4.10, U4.11, U4.19, U5.7 (~E), U5.8 (GND), U6.7 (~E), U6.8 (GND), U7.7 (~E), U7.8 (GND)
unnamed: B3.1, RN3.2 (R1), U7.15 (I4)
unnamed: B4.1, RN3.3 (R2), U7.14 (I5)
unnamed: B5.1, RN3.4 (R3), U7.13 (I6)
unnamed: B6.1, RN3.5 (R4), U7.12 (I7)
unnamed: B7.1, RN3.9 (R8), U7.4 (I0)
unnamed: B8.1, RN3.8 (R7), U7.3 (I1)
unnamed: B9.1, RN3.6 (R5), U7.1 (I3)
unnamed: B10.1, RN3.7 (R6), U7.2 (I2)
unnamed: D1.1 (e), R5.1
unnamed: D1.2 (d), R4.1
unnamed: D1.3 (DPX), R8.1
unnamed: D1.4 (c), R3.1
unnamed: D1.5 (g), R7.1
unnamed: D1.6 (CC4), U2.7
unnamed: D1.9 (b), R2.1
unnamed: D1.10 (CC3), U2.6
unnamed: D1.11 (CC2), U2.5
unnamed: D1.12 (f), R6.1
unnamed: D1.13 (a), R1.1
unnamed: D1.14 (CC1), U2.4
unnamed: D2.1 (e), R13.1
unnamed: D2.2 (d), R12.1
unnamed: D2.3 (DPX), R16.1
unnamed: D2.4 (c), R11.1
unnamed: D2.5 (g), R15.1
unnamed: D2.6 (CC4), U2.17
unnamed: D2.9 (b), R10.1
unnamed: D2.10 (CC3), U2.16
unnamed: D2.11 (CC2), U2.15
unnamed: D2.12 (f), R14.1
unnamed: D2.13 (a), R9.1
unnamed: D2.14 (CC1), U2.14
unnamed: D3.1 (e), R21.1
unnamed: D3.2 (d), R20.1
unnamed: D3.3 (DPX), R24.1
unnamed: D3.4 (c), R19.1
unnamed: D3.5 (g), R23.1
unnamed: D3.6 (CC4), U4.17
unnamed: D3.9 (b), R18.1
unnamed: D3.10 (CC3), U4.16
unnamed: D3.11 (CC2), U4.15
unnamed: D3.12 (f), R22.1
unnamed: D3.13 (a), R17.1
unnamed: D3.14 (CC1), U4.14
unnamed: D4.1 (e), R29.1
unnamed: D4.2 (d), R28.1
unnamed: D4.3 (DPX), R32.1
unnamed: D4.4 (c), R27.1
unnamed: D4.5 (g), R31.1
unnamed: D4.6 (CC4), U4.7
unnamed: D4.9 (b), R26.1
unnamed: D4.10 (CC3), U4.6
unnamed: D4.11 (CC2), U4.5
unnamed: D4.12 (f), R30.1
unnamed: D4.13 (a), R25.1
unnamed: D4.14 (CC1), U4.4
unnamed: R1.2, R9.2, U1.15 (QA)
unnamed: R2.2, R10.2, U1.1 (QB)
unnamed: R3.2, R11.2, U1.2 (QC)
unnamed: R4.2, R12.2, U1.3 (QD)
unnamed: R5.2, R13.2, U1.4 (QE)
unnamed: R6.2, R14.2, U1.5 (QF)
unnamed: R7.2, R15.2, U1.6 (QG)
unnamed: R8.2, R16.2, U1.7 (QH)
unnamed: R17.2, R25.2, U3.15 (QA)
unnamed: R18.2, R26.2, U3.1 (QB)
unnamed: R19.2, R27.2, U3.2 (QC)
unnamed: R20.2, R28.2, U3.3 (QD)
unnamed: R21.2, R29.2, U3.4 (QE)
unnamed: R22.2, R30.2, U3.5 (QF)
unnamed: R23.2, R31.2, U3.6 (QG)
unnamed: R24.2, R32.2, U3.7 (QH)
unnamed: R33.1, U2.8
unnamed: R34.1, U4.8
unnamed: RN1.2 (R1), SW4.2, U5.1 (I3)
unnamed: RN1.3 (R2), SW4.3, U5.2 (I2)
unnamed: RN1.4 (R3), SW4.4, U5.3 (I1)
unnamed: RN1.5 (R4), SW4.5, U5.4 (I0)
unnamed: RN1.6 (R5), SW3.2, U5.15 (I4)
unnamed: RN1.7 (R6), SW3.3, U5.14 (I5)
unnamed: RN1.8 (R7), SW3.4, U5.13 (I6)
unnamed: RN1.9 (R8), SW3.5, U5.12 (I7)
unnamed: RN2.2 (R1), SW6.2, U6.1 (I3)
unnamed: RN2.3 (R2), SW6.3, U6.2 (I2)
unnamed: RN2.4 (R3), SW6.4, U6.3 (I1)
unnamed: RN2.5 (R4), SW6.5, U6.4 (I0)
unnamed: RN2.6 (R5), SW5.2, U6.15 (I4)
unnamed: RN2.7 (R6), SW5.3, U6.14 (I5)
unnamed: RN2.8 (R7), SW5.4, U6.13 (I6)
unnamed: RN2.9 (R8), SW5.5, U6.12 (I7)

Notes on the sheet:
Switch Sense 1
Switch Sense 2
Button Sense
Display Bank 1
Display Bank 2
Arduino

Board: 2 copper layers, 208.3 x 127.0 mm, 77 parts (0 on the bottom side), 110 nets.

## Commit log

2020-08-04 initial schematic sketch
2020-08-05 Get schematic more complete
2020-08-07 Complete PCB layout
2020-08-07 Fix TPIC pinout
2020-08-08 Complete PCB layout. Purchased version
2020-08-17 Begin working on firmware
2020-08-17 Add experimental FW tests into repo
2020-08-17 Rename PCB folder
2020-08-17 Rename Arduino project
2020-08-18 Begin stubbing out display driver
2020-08-18 Fix A6 A7 digital mode bug (SCHEMATIC ONLY)
2020-08-18 Add datasheet for actual 74x151 used
2020-08-18 Complete switch and button sensing with hardware
2020-08-19 Update resistor values for displays. Remove power switch resistor
2020-08-19 Achieve minimum viable product (4 independent counters, no cmdr damage)
2020-08-21 Refactor roll into separate function
2020-08-21 Add ability to reset individual counter by pressing both buttons at once
2020-08-21 Refactor button stuff, add text option to display
2020-08-21 Display roll result
2020-08-21 Get commander damage display almost there
2020-08-22 Add commander damange tracking with the rotary switches
2020-08-22 Fix bug in rotary init
2020-08-23 Minor clenaup
2020-08-23 Fix high current drain during sleep
2020-08-23 Actually fix standby current issue. Add core temp instrumentation
2020-08-24 refactor counter min/max detection
2020-08-24 Move core temperature to separate module
2020-08-24 Add TODO file
2020-08-24 Add VSCode config
2020-08-24 Apply templates to config, animations, sevenseg
2020-08-24 Use 30 starting life if reset is held when mode switch is changed
2020-08-24 Four space tabs
2020-08-25 Refactor and apply style guide to display module
2020-08-25 Update TODO
2020-08-25 add style guide templates
2020-08-25 Move templates to folder
2020-08-25 Update templates
2020-08-25 Update switches module to match style guide
2020-08-25 Cleanup switches
2020-08-25 Minor style cleanup
2020-08-25 Update VSCode settings
2020-08-25 Refactor switches module
2020-08-25 Formatting cleanup in main
2020-08-26 Remove character fill from the roll loser displays
2020-08-26 Begin roll refactor
2020-08-26 complete roll refactor
2020-08-26 Cleanup
2020-08-26 Add debouncing to the switch zero-state
2020-08-26 Displays temporarily show change in totals ('delta' display)
2020-08-26 Resolve TODOs
2020-08-26 Fix timer rollover in roll module
2020-08-28 Remove printout from switches rotary read
2020-08-30 begin design plan for mini
2020-08-31 Sketch out mini pcb
2020-08-31 Add support for 5-position rotaries
2020-08-31 Minor cleanup in counter reset
2020-09-01 copy in encoders sketch
2020-09-01 Add datasheets specific to mini
2020-09-01 Continue updating schematic
2020-09-02 Continue work on mini PCB
2020-09-02 Add TagConnect datasheet
2020-09-03 Continue work on mini version
2020-09-04 Add option to enable adaptive rolling
2020-09-14 Add additional Luckylight datasheets
2020-09-14 Tweak layout
2020-09-14 Mess w timer excel
2020-12-31 complete electrical layout
2021-02-11 Switch to 74x165. Optimize pin assignments
2021-02-12 Finish routing
2021-02-12 Fill some zones
2021-02-12 Add comments from design review
2021-11-22 Switch to SMD 7segs
2021-11-23 Complete layout. Use new USB-C connector
2021-11-25 Tweak encoder footprint. Add more via stitching
2021-11-25 Copy firmware changes from master
2021-11-25 Begin updating firmware to match new hardware
2021-11-26 Separate display and encoder latch lines
2021-11-29 Add protection diode. Finalize test points + jumpers
2021-12-08 Resolve design review issues
2021-12-08 Add silkscreen outline to LED displays
2021-12-08 Update date in schematics. Update PDF
2021-12-17 Start to remove old software implementation
2021-12-17 Fix display ordering
2021-12-21 Get display test working
2021-12-24 Get basic functionality working
2021-12-24 Refactor counter control into separte files
2021-12-29 Get button detection working
2021-12-30 Sort of get display mode switching to work
2022-04-09 Please read
    can email me back if you would like at bobby.grant15@gmail.com
2024-03-22 Apply license
2024-03-22 Update gitignore
2024-03-22 Update to KiCad 8 and clean up files
2024-04-07 Update README, fix Arduino.h includes
2025-12-31 wip on common cathode with transistors design
2025-12-31 tentative schematic for common cathode
2026-01-01 common anode schematic
2026-01-01 continue wip
2026-01-01 update datasheets
2026-01-01 start to route display traces
2026-01-01 add BOM
2026-01-03 switch to all smd components
2026-01-04 continue layout. improve 3d model
2026-01-04 button text alignment
2026-01-05 continue layout. update bom
2026-01-10 add new led datasheets
2026-02-21 continue layout. update leds for KD4 led modules
2026-02-22 complete routing
2026-05-31 quick code cleanup (incl formatting)
2026-05-31 more cleanup
2026-05-31 stop/start display interrupt around functions that modify the shared buffer
